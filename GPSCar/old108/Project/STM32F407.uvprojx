# Keil uVision project STM32F407.uvprojx, settings and files
target STM32F407 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,ARM_MATH_CM4,
  c include: ..\STM32\CMSIS\Device\ST\STM32F4xx\Include;..\STM32\CMSIS\Include;..\STM32\STM32F4xx_StdPeriph_Driver\inc;..\MY;..\Drive\Include;..\Program\Include;..\Mid\Inc;..\BSP\Inc;..\FatFs;..\RTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MY
    ../MY/: main.c stm32f4xx_it.c stm32f4xx_conf.h
  group Drive
    ../Drive/Source/: led.c delay.c key.c usart.c lcd_fonts.c lcd_image.c lcd_spi_154.c timer.c motor.c encoder.c mpu6050.c sensor_adc.c servo.c ultrasonic.c buzzer.c car_led.c car_key.c
    ../Drive/Include/: led.h delay.h key.h usart.h lcd_fonts.h lcd_image.h lcd_spi_154.h timer.h motor.h encoder.h mpu6050.h sensor_adc.h servo.h ultrasonic.h buzzer.h car_led.h car_key.h
  group STM32
    ../STM32/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
    ../STM32/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../STM32/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_sdio.c
  group Fat
    ../FatFs/: diskio.c diskio.h ff.c ff.h ffconf.h ffunicode.c sdio_sd.c sdio_sd.h ffsystem.c integer.h
  group program
    ../Program/Source/: car.c gps.c bluetooth.c asrpro.c K230.c lanyacon.c
    ../Program/Include/: car.h gps.h bluetooth.h asrpro.h K230.h lanyacon.h
  group Mid
    ../Mid/Src/: location.c navlog.c mapview.c menu.c
    ../Mid/Inc/: location.h navlog.h mapview.h menu.h
  group BSP
    ../BSP/Src/: bsp.c
    ../BSP/Inc/: bsp.h
